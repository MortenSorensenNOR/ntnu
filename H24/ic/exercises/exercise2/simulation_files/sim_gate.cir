.include ../models/p18_cmos_models_tt.inc

MN1 DRAIN GATE SOURCE BULK NMOS L=0.5U W=5U

Vbuild BULK 0 0
Vgs GATE 0 DC 0
Vds DTAIN SOURCE DC 1.8
Vsource SOURCE 0 0

.dc Vgs 0 1.8 0.01
.dc Vds 0 1.8 0.01

.op
.print dc i(drain) gm(MN1) rds (MN1)
