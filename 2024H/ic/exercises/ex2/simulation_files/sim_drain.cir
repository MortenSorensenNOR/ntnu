.include /home/morten/ntnu/2024H/ic/exercises/exercise2/models/p18_cmos_models_tt.inc

M1 D G S 0 NMOS

Vg G 0 DC 0.9
Vs S 0 0
Vd D 0 DC 0
.dc Vd 0 1.8 0.01

.plot i(vd)
.plot gm(m1)
.plot rds(m1)
